// This file was generated from a template. Edit it to match your keyboard.
// See https://zmk.dev/docs/development/new-shield for more instructions.

#include <behaviors.dtsi>
#include <dt-bindings/zmk/keys.h>

/ {
    // Define a default keymap here.
    // See https://zmk.dev/docs/development/new-shield#default-keymap.
    keymap {
        compatible = "zmk,keymap";

<%block name="layers">
        default_layer {
            bindings = <
                &kp A &kp B
                &kp C &kp D
            >;
        };
</%block>
    };
};
${self.body()}